# Keil uVision project vibrate.uvprojx, settings and files
target vibrate (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vibrate +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\BSP\BSP_LED;..\BSP\BSP_KEY;..\BSP\BSP_UART;..\BSP\BSP_GPIO;..\BSP\BSP_GeneralTim
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../BSP/BSP_LED/: bsp_led.c
    ../BSP/BSP_UART/: bsp_usart.c
    ../BSP/BSP_KEY/: bsp_key.c
    ../BSP/BSP_GPIO/: bsp_gpio.c
    ../BSP/BSP_GeneralTim/: bsp_GeneralTim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group STARTUP
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group SEGGER/HardFalut
    ../segger/HardFaultHandlerMDK/: SEGGER_HardFaultHandler.c HardFaultHandler.S
